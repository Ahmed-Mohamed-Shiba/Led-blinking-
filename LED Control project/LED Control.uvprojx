# Keil uVision project LED Control.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED Control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Common;.\Config;.\Hal\Inc;.\Mcal\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Common
    ./Common/: Common_Macros.h Compiler.h Platform_Types.h Std_Types.h
  group MCAL
    ./Mcal/: Gpio.c Gpt.c IntCtrl.c
    ./Mcal/Inc/: Gpio.h Gpio_Types.h Gpt.h IntCtrl.h
  group Config
    ./Config/: Gpio_Cfg.h Gpio_PBcfg.c
  group App
    ./App/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
